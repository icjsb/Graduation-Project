# Keil uVision project main.uvproj, settings and files
target Voice Assistant (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\blueteeth;.\delay;.\main;.\mp3;.\serial;.\voice;.\key;.\ds3231
  group Main
    ./main/: main.c
  group Delay
    ./delay/: delay.c
  group MP3
    ./mp3/: mp3.c
  group Key
    ./key/: key.c
  group Voice
    ./voice/: voice.c
  group Blueteeth
    ./blueteeth/: blueteeth.c
  group Serial
    ./serial/: serial.c
  group Ds3231
    ./ds3231/: ds3231.c
